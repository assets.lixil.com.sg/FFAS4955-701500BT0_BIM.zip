Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T10:04:04
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
FlowDirection: SINK
Pset_DistributionPortPipe - ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 15 mm; ConnectorDiameter: 15 mm; NominalWidth: 15 mm; NominalHeight: 15 mm
Name | PortNumber
 | 1
 | 2

# IfcEnergyConversionDevice: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit, FFAS4955-701500BT0:EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit:3549
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Data - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: Bathroom Fittings (40); ProductGroup: Thermostats (01); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Thermostats (44)
Type - Identity Data - Assembly Code: C1030200; Description: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; Keynote: N13; Manufacturer: American Standard; Model: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; OmniClass Number: 23.65.55.14.24; OmniClass Title: Mixing Valves for Liquid Services; Type Comments: FFAS4955-701500BT0; Type Name: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; URL: https://www.americanstandard-apac.com/
Type - Model Properties - _Author: JY; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffas4955-701500bt0/document/object-user-guide; BIMObjectName: AmericanStandard_Thermostat_EasySET _(FFAS4955-701500BT0); NBSDescription: Thermostatic mixing valves; NBSNote: n/a; NBSObjectName: American Standard - Thermostatic mixing valves; NBSOfficeMasterTag: n/a; NBSReference: 90-10-90/370
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_65_54_95_88; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffas4955-701500bt0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffas4955-701500bt0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffas4955-701500bt0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffas4955-701500bt0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffas4955-701500bt0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: FFAS4955-701500BT0; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: FFAS4955-701500BT0; ModelReference: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
Pset_ManufacturerTypeInformation - ModelReference: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit
Constraints - Elevation: 0 mm
Dimensions - Area: 0.201961 m2; Volume: 0.00391967 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Family: FFAS4955-701500BT0: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; Family and Type: FFAS4955-701500BT0: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: FFAS4955-701500BT0: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; Type Id: FFAS4955-701500BT0: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcValveType, no part of this type: EasySet Exposed Shower Auto Temperature Mixer with Integrated Rainshower Kit
Classification: C1030200 (Uniformat); Material: Chrome
